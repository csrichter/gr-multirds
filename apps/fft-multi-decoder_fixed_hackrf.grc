<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fft_multi_fixed</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_decim</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baseband_rate</value></param>
<param><key>value</key><value>chan_rate/bb_decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bb_decim</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bbgain</value></param>
<param><key>value</key><value>26</value></param>
<param><key>gui_hint</key><value>tabs@0:gainrow,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>62</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bbgain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>26</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_fft_len</value></param>
<param><key>value</key><value>512*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_rate</value></param>
<param><key>value</key><value>audio_rate*audio_decim*bb_decim</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cutpoint1</value></param>
<param><key>value</key><value>550</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@0:1,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>50</value></param>
<param><key>stop</key><value>fft_len</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cutpoint2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@0:1,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>50</value></param>
<param><key>stop</key><value>fft_len</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cutpoint3</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@0:1,3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>50</value></param>
<param><key>stop</key><value>fft_len</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cutpoint4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@0:2,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>50</value></param>
<param><key>stop</key><value>fft_len</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cutpoint5</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@0:2,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>50</value></param>
<param><key>stop</key><value>fft_len</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cutpoint6</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@0:2,3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>50</value></param>
<param><key>stop</key><value>fft_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>1024*40</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq1</value></param>
<param><key>comment</key><value>SWR3</value></param>
<param><key>value</key><value>922e5</value></param>
<param><key>gui_hint</key><value>tabs@0:1,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>86e6</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>108e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq2</value></param>
<param><key>value</key><value>94700000</value></param>
<param><key>gui_hint</key><value>tabs@0:1,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>86e6</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>108e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq3</value></param>
<param><key>value</key><value>101300000</value></param>
<param><key>gui_hint</key><value>tabs@0:1,3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>86e6</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>108e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq4</value></param>
<param><key>value</key><value>102300000</value></param>
<param><key>gui_hint</key><value>tabs@0:2,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>86e6</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>108e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq5</value></param>
<param><key>value</key><value>105700000</value></param>
<param><key>gui_hint</key><value>tabs@0:2,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>86e6</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>108e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq6</value></param>
<param><key>value</key><value>107700000</value></param>
<param><key>gui_hint</key><value>tabs@0:2,3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>86e6</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>108e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq7</value></param>
<param><key>value</key><value>89500000</value></param>
<param><key>gui_hint</key><value>tabs@0:3,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>86e6</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>108e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq8</value></param>
<param><key>value</key><value>90100000</value></param>
<param><key>gui_hint</key><value>tabs@0:3,2,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>86e6</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>108e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq9</value></param>
<param><key>value</key><value>90800000</value></param>
<param><key>gui_hint</key><value>tabs@0:3,3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>86e6</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>108e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_tune</value></param>
<param><key>value</key><value>98800000</value></param>
<param><key>gui_hint</key><value>tabs@0:0,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>86e6</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>108e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gainrow</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>hackrf_bw</value></param>
<param><key>value</key><value>samp_rate/1.7</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e6</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>20e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hackrf_bw</value></param>
<param><key>value</key><value>11.3e6+3e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ifgain</value></param>
<param><key>value</key><value>33</value></param>
<param><key>gui_hint</key><value>tabs@0:gainrow,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ifgain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>13</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>loop_bw</value></param>
<param><key>value</key><value>470</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>700</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>num_zeros</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>chan_fft_len/2</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_zeros</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rec_folder</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"/tmp/"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>value</key><value>16</value></param>
<param><key>gui_hint</key><value>tabs@0:gainrow,3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>62</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>chan_rate*fft_len/chan_fft_len</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>volume</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>gui_hint</key><value>tabs@0:0,2,1,1</value></param>
<param><key>label</key><value>volumeLR</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>volume2</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>gui_hint</key><value>tabs@0:0,3,1,1</value></param>
<param><key>label</key><value>volumeM</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0_0_0_0_0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0_0_0_1</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0_0_1</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>volume2/2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0</value></param>
<param><key>const</key><value>volume2/2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_len</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt
from threading import Timer
#import time
class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, freqlist=[92200000,94700000,101300000,102300000,105700000,107700000]):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='freq-setter',   # will show up in GRC
            in_sig=None,
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self._freqlist=freqlist
        self.message_port_register_out(pmt.intern('out'))
	self.send_msg()
	Timer(3, self.send_msg).start() #after 3 seconds (when table initialized)
	#self.time=time.time()
    @property
    def freqlist(self):
	"""I'm the 'freqlist' property."""
	return self._freqlist

    @freqlist.setter
    def freqlist(self, value):
	self._freqlist = value
	self.send_msg()

    @freqlist.deleter
    def freqlist(self):
	del self._freqlist
    def send_msg(self):
      #print(self.freqlist)
      for i,freq in enumerate(self.freqlist):
	send_string=str(i+1)+" "+str(freq)
	send_pmt = pmt.string_to_symbol(send_string)
	self.message_port_pub(pmt.intern('out'), send_pmt)
    #def work(self, input_items, output_items):
      #print("work")
      #now=time.time()
      #if now-self.time &gt;2:
        #self.time=now
        #self.send_msg()
      #return len(input_items[0])</value></param>
<param><key>freqlist</key><value>[freq1,freq2,freq3,freq4,freq5,freq6,freq7,freq8,freq9]</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>2</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>[]</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0,baseband_rate,13e3,3e3,firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0_0</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0,baseband_rate,13e3,3e3,firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0_0_0</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0,baseband_rate,13e3,3e3,firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0_0_0_0</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0,baseband_rate,13e3,3e3,firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0_0_1</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0,baseband_rate,13e3,3e3,firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0_1</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0,baseband_rate,13e3,3e3,firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>hier_ifft_decoder</key>
<param><key>id</key><value>hier_ifft_decoder_0</value></param>
<param><key>chan_fft_len</key><value>chan_fft_len</value></param>
<param><key>cutpoint</key><value>(freq1-freq_tune)*fft_len/samp_rate-chan_fft_len/2+fft_len/2</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>log</key><value>False</value></param>
<param><key>loop_bw</key><value>3.14/loop_bw</value></param>
<param><key>num_zeros</key><value>num_zeros</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>hier_ifft_decoder</key>
<param><key>id</key><value>hier_ifft_decoder_0_0</value></param>
<param><key>chan_fft_len</key><value>chan_fft_len</value></param>
<param><key>cutpoint</key><value>(freq2-freq_tune)*fft_len/samp_rate-chan_fft_len/2+fft_len/2</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>log</key><value>False</value></param>
<param><key>loop_bw</key><value>3.14/loop_bw</value></param>
<param><key>num_zeros</key><value>num_zeros</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>hier_ifft_decoder</key>
<param><key>id</key><value>hier_ifft_decoder_0_1</value></param>
<param><key>chan_fft_len</key><value>chan_fft_len</value></param>
<param><key>cutpoint</key><value>(freq3-freq_tune)*fft_len/samp_rate-chan_fft_len/2+fft_len/2</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>log</key><value>False</value></param>
<param><key>loop_bw</key><value>3.14/loop_bw</value></param>
<param><key>num_zeros</key><value>num_zeros</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>hier_ifft_decoder</key>
<param><key>id</key><value>hier_ifft_decoder_0_1_0</value></param>
<param><key>chan_fft_len</key><value>chan_fft_len</value></param>
<param><key>cutpoint</key><value>(freq4-freq_tune)*fft_len/samp_rate-chan_fft_len/2+fft_len/2</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>log</key><value>False</value></param>
<param><key>loop_bw</key><value>3.14/loop_bw</value></param>
<param><key>num_zeros</key><value>num_zeros</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>hier_ifft_decoder</key>
<param><key>id</key><value>hier_ifft_decoder_0_1_1</value></param>
<param><key>chan_fft_len</key><value>chan_fft_len</value></param>
<param><key>cutpoint</key><value>(freq5-freq_tune)*fft_len/samp_rate-chan_fft_len/2+fft_len/2</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>log</key><value>False</value></param>
<param><key>loop_bw</key><value>3.14/loop_bw</value></param>
<param><key>num_zeros</key><value>num_zeros</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>hier_ifft_decoder</key>
<param><key>id</key><value>hier_ifft_decoder_0_1_2</value></param>
<param><key>chan_fft_len</key><value>chan_fft_len</value></param>
<param><key>cutpoint</key><value>(freq6-freq_tune)*fft_len/samp_rate-chan_fft_len/2+fft_len/2</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>log</key><value>False</value></param>
<param><key>loop_bw</key><value>3.14/loop_bw</value></param>
<param><key>num_zeros</key><value>num_zeros</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>hier_ifft_decoder</key>
<param><key>id</key><value>hier_ifft_decoder_0_1_2_0</value></param>
<param><key>chan_fft_len</key><value>chan_fft_len</value></param>
<param><key>cutpoint</key><value>(freq7-freq_tune)*fft_len/samp_rate-chan_fft_len/2+fft_len/2</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>log</key><value>False</value></param>
<param><key>loop_bw</key><value>3.14/loop_bw</value></param>
<param><key>num_zeros</key><value>num_zeros</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>hier_ifft_decoder</key>
<param><key>id</key><value>hier_ifft_decoder_0_1_2_0_0</value></param>
<param><key>chan_fft_len</key><value>chan_fft_len</value></param>
<param><key>cutpoint</key><value>(freq8-freq_tune)*fft_len/samp_rate-chan_fft_len/2+fft_len/2</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>log</key><value>False</value></param>
<param><key>loop_bw</key><value>3.14/loop_bw</value></param>
<param><key>num_zeros</key><value>num_zeros</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>hier_ifft_decoder</key>
<param><key>id</key><value>hier_ifft_decoder_0_1_2_0_0_0</value></param>
<param><key>chan_fft_len</key><value>chan_fft_len</value></param>
<param><key>cutpoint</key><value>(freq9-freq_tune)*fft_len/samp_rate-chan_fft_len/2+fft_len/2</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>log</key><value>False</value></param>
<param><key>loop_bw</key><value>3.14/loop_bw</value></param>
<param><key>num_zeros</key><value>num_zeros</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>multirds_decoder_compare</key>
<param><key>id</key><value>multirds_decoder_compare_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>nPorts</key><value>6</value></param>
</block>
<block>
<key>multirds_rds_parser_table_qt</key>
<param><key>id</key><value>multirds_rds_parser_table_qt_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1:7,1,5,3</value></param>
<param><key>label</key><value></value></param>
<param><key>log</key><value>False</value></param>
<param><key>nPorts</key><value>9</value></param>
<param><key>freq_tune</key><value>freq_tune</value></param>
<param><key>workdir</key><value>/user/wire2/richter/data/</value></param>
<param><key>writeDB</key><value>True</value></param>
</block>
<block>
<key>multirds_stream_router</key>
<param><key>id</key><value>multirds_stream_router_0</value></param>
<param><key>ninputs</key><value>9</value></param>
<param><key>noutputs</key><value>3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>multirds_tmc_parser</key>
<param><key>id</key><value>multirds_tmc_parser_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
<param><key>label</key><value></value></param>
<param><key>log</key><value>False</value></param>
<param><key>maxheight</key><value>0</value></param>
<param><key>workdir</key><value>/user/wire2/richter/data/</value></param>
<param><key>writeDB</key><value>True</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>bbgain</value></param>
<param><key>bw0</key><value>hackrf_bw</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>freq_tune</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>ifgain</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>comment</key><value>RF gain 0 = amp off</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>axislabels</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@0:5,3,1,1</value></param>
<param><key>nconnections</key><value>6</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
<param><key>key</key><value>0</value></param>
<param><key>is_static</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_1</value></param>
<param><key>axislabels</key><value>False</value></param>
<param><key>bw</key><value>chan_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>chan_fft_len</value></param>
<param><key>gui_hint</key><value>tabs@0:5,1,1,1</value></param>
<param><key>label2</key><value></value></param>
<param><key>label3</key><value></value></param>
<param><key>label4</key><value></value></param>
<param><key>label5</key><value></value></param>
<param><key>label6</key><value></value></param>
<param><key>nconnections</key><value>6</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>70</value></param>
<param><key>ymin</key><value>-60</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_1_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq_tune</value></param>
<param><key>fftsize</key><value>2048*2</value></param>
<param><key>gui_hint</key><value>tabs@0:4,1,1,3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_1_2</value></param>
<param><key>axislabels</key><value>False</value></param>
<param><key>bw</key><value>baseband_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>chan_fft_len</value></param>
<param><key>gui_hint</key><value>tabs@0:5,2,1,1</value></param>
<param><key>label2</key><value></value></param>
<param><key>label3</key><value></value></param>
<param><key>label4</key><value></value></param>
<param><key>label5</key><value></value></param>
<param><key>label6</key><value></value></param>
<param><key>name</key><value></value></param>
<param><key>nconnections</key><value>6</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>label0</key><value>graphs</value></param>
<param><key>label1</key><value>table</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>analog_fm_deemph_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_deemph_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_deemph_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_deemph_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_deemph_0_0_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_deemph_0_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_1</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1</source_block_id><sink_block_id>blocks_add_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>blocks_add_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>multirds_rds_parser_table_qt_0_0</sink_block_id><source_key>out</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>hier_ifft_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>hier_ifft_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>hier_ifft_decoder_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>hier_ifft_decoder_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>hier_ifft_decoder_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>hier_ifft_decoder_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>hier_ifft_decoder_0_1_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>hier_ifft_decoder_0_1_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>hier_ifft_decoder_0_1_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>analog_fm_deemph_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0</source_block_id><sink_block_id>analog_fm_deemph_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0_0</source_block_id><sink_block_id>analog_fm_deemph_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0_0_0</source_block_id><sink_block_id>analog_fm_deemph_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0_1</source_block_id><sink_block_id>analog_fm_deemph_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_1</source_block_id><sink_block_id>analog_fm_deemph_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0</source_block_id><sink_block_id>multirds_stream_router_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0</source_block_id><sink_block_id>multirds_decoder_compare_0</sink_block_id><source_key>rds</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0</source_block_id><sink_block_id>multirds_rds_parser_table_qt_0_0</sink_block_id><source_key>rds</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_0</source_block_id><sink_block_id>fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_0</source_block_id><sink_block_id>multirds_stream_router_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_1_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_0</source_block_id><sink_block_id>multirds_decoder_compare_0</sink_block_id><source_key>rds</source_key><sink_key>in1</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_0</source_block_id><sink_block_id>multirds_rds_parser_table_qt_0_0</sink_block_id><source_key>rds</source_key><sink_key>in1</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1</source_block_id><sink_block_id>fir_filter_xxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1</source_block_id><sink_block_id>multirds_stream_router_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_1_2</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_1</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1</source_block_id><sink_block_id>multirds_decoder_compare_0</sink_block_id><source_key>rds</source_key><sink_key>in2</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1</source_block_id><sink_block_id>multirds_rds_parser_table_qt_0_0</sink_block_id><source_key>rds</source_key><sink_key>in2</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_0</source_block_id><sink_block_id>multirds_stream_router_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_1_2</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_1</sink_block_id><source_key>1</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_0</source_block_id><sink_block_id>multirds_decoder_compare_0</sink_block_id><source_key>rds</source_key><sink_key>in3</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_0</source_block_id><sink_block_id>multirds_rds_parser_table_qt_0_0</sink_block_id><source_key>rds</source_key><sink_key>in3</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_1</source_block_id><sink_block_id>multirds_stream_router_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_1_2</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_1</sink_block_id><source_key>1</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_1</source_block_id><sink_block_id>multirds_decoder_compare_0</sink_block_id><source_key>rds</source_key><sink_key>in4</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_1</source_block_id><sink_block_id>multirds_rds_parser_table_qt_0_0</sink_block_id><source_key>rds</source_key><sink_key>in4</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_2</source_block_id><sink_block_id>multirds_stream_router_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_2</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_1_2</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_2</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_1</sink_block_id><source_key>1</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_2</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_2</source_block_id><sink_block_id>multirds_decoder_compare_0</sink_block_id><source_key>rds</source_key><sink_key>in5</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_2</source_block_id><sink_block_id>multirds_rds_parser_table_qt_0_0</sink_block_id><source_key>rds</source_key><sink_key>in5</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_2_0</source_block_id><sink_block_id>multirds_stream_router_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_2_0</source_block_id><sink_block_id>multirds_rds_parser_table_qt_0_0</sink_block_id><source_key>rds</source_key><sink_key>in6</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_2_0_0</source_block_id><sink_block_id>multirds_stream_router_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_2_0_0</source_block_id><sink_block_id>multirds_rds_parser_table_qt_0_0</sink_block_id><source_key>rds</source_key><sink_key>in7</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_2_0_0_0</source_block_id><sink_block_id>multirds_stream_router_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>hier_ifft_decoder_0_1_2_0_0_0</source_block_id><sink_block_id>multirds_rds_parser_table_qt_0_0</sink_block_id><source_key>rds</source_key><sink_key>in8</sink_key></connection>
<connection><source_block_id>multirds_rds_parser_table_qt_0_0</source_block_id><sink_block_id>multirds_stream_router_0</sink_block_id><source_key>ctrl</source_key><sink_key>ctrl</sink_key></connection>
<connection><source_block_id>multirds_rds_parser_table_qt_0_0</source_block_id><sink_block_id>multirds_tmc_parser_0</sink_block_id><source_key>tmc_raw</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>multirds_stream_router_0</source_block_id><sink_block_id>fir_filter_xxx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multirds_stream_router_0</source_block_id><sink_block_id>fir_filter_xxx_0_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multirds_stream_router_0</source_block_id><sink_block_id>fir_filter_xxx_0_0_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0</source_block_id><sink_block_id>multirds_stream_router_0</sink_block_id><source_key>msg</source_key><sink_key>ctrl</sink_key></connection>
</flow_graph>
